# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ADC0832.c ADC0832.h AT24C02.h common.c common.h DS18B20_One_1.h LCD.C LCD.h lcd1602.c lcd1602.h uart.c uart.h user.c

# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c AT24C02.c AT24C02.h I2C.c I2C.h
    ../11-1 蜂鸣器/: Delay.c Delay.h
    ../5-2 LCD1602调试工具/: LCD1602.c LCD1602.h
    ../7-1定时器/: Key.c Key.h
